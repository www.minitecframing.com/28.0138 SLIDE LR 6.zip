# Autodesk Inventor assembly: 28.0138 SLIDE LR 6
## iProperties
Created: 2007-06
Part Number: 28.0138 SLIDE LR 6
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
